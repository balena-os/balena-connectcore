# Already installed by linux-firmware-atheros-license
FW_QCA65X4_SDIO_PROPRIETARY_remove = "file://LICENCE.atheros_firmware"
FW_QCA65X4_PCIE_PROPRIETARY_remove = "file://LICENCE.atheros_firmware"
