ATF_SRC = "git://github.com/nxp-imx/imx-atf.git;protocol=https"
