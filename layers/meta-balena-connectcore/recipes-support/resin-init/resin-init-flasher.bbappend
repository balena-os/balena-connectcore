INTERNAL_DEVICE_KERNEL_ccimx8x = "mmcblk0"
