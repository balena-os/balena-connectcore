FILESEXTRAPATHS_append := "${THISDIR}/${BPN}:"
