PACKAGE_INSTALL_append_ccimx8x = " firmware-imx-vpu-imx8 firmware-imx-sdma"
